options:
  parameters:
    author: thomas@habets.se
    copyright: Copyright (c) 2018, Thomas Habets
    description: Derived from https://github.com/ThomasHabets/radiostuff/tree/master/broadband-scan
    generate_options: no_gui
    id: ettus_scan
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: ettus_scan
  states: {}

blocks:
- name: center_freq
  id: variable_function_probe
  parameters:
    block_id: blocks_probe_signal_x_0
    function_name: level
    poll_rate: '97'
    value: freq_start
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: scan_samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sweep_freq
  id: variable
  parameters:
    value: 1/sweep_sec
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: sweep_freq
    offset: '0'
    phase: '0'
    samp_rate: scan_samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: freq_start
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: logfile
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: freq_end-freq_start
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: scan_samp_rate
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: freq_end
  id: parameter
  parameters:
    type: eng_float
    value: 1e9
  states: {}
- name: freq_start
  id: parameter
  parameters:
    type: eng_float
    value: 100e6
  states: {}
- name: habets39_sweepsinkv_0
  id: habets39_sweepsinkv
  parameters:
    samp_rate: samp_rate
    tag: rx_freq
    vlen: fft_size
  states: {}
- name: igain
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: logfile
  id: parameter
  parameters:
    type: str
    value: /logs/ettus_scan.csv
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 4e6
  states: {}
- name: sweep_sec
  id: parameter
  parameters:
    type: intx
    value: '30'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: igain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_mag_0, '0', habets39_sweepsinkv_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_probe_signal_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [habets39_sweepsinkv_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
